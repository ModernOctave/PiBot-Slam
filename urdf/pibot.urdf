Commit message: Updated urdf

File: urdf/pibot.urdf (robot description, URDF)
Before this commit: robot rur, 2 links, 1 joints
Joints:
- joint base_link_to_laser: origin xyz=0.0 0 0.240 rpy=0.0 0.0 0.0 -> xyz=0.0 0 0.120 rpy=0.0 0.0 0.0
